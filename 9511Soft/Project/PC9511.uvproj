# Keil uVision project PC9511.uvproj, settings and files
target V8_9511_V0 (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 103V8 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\Source\APP;..\Source\APP\MC;..\Source\BSP;..\Source\FS\FF007;..\Source\OS\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\Source\OS\uCOS-II\Source;..\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source\Libraries\CMSIS\Core\CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../Source/APP/: app.c stm32f10x_it.c c491.c dbg.c moto.c in.c com.c hdled.c
  group APP_MC
    ../Source/APP/mc/: mc_base.c mc_open.c mc_close_low.c mc_close_high.c mc_cmd.c
  group BSP
    ../Source/BSP/: bsp.c io.c
  group OS_PORTS
    ../Source/OS/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group OS_CORE
    ../Source/OS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group LIB_STDPERIPH
    ../Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LIB_CMSIS
    ../Source/Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
    ../Source/Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md_os.s
  group DES3
    ../Source/3DS/: bitstream.c crypto_des3.c
  group PRO
    ../Source/FZQ/: UID_COUN.c
  group Key
    ../Source/Key/: des3key.c
target VB_9511_V0 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 103VB +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target V8_9511_V1 (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: as above
  output: 103V8_ceshi +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD, HARDWARE_VER = 1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target V8_924 (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: as above
  output: 103V8_924 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,PC924
  c include: ..\Source\APP;..\Source\APP\MC;..\Source\BSP;..\Source\OS\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\Source\OS\uCOS-II\Source;..\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source\Libraries\CMSIS\Core\CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target VB_924 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: 103VB_924 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,PC924
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target V8_924_OBSERVE (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: as above
  output: 103V8_924 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,PC924,MC_IS_OBSERVE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
